# IAR project neo_watch.ewp, settings and files
configuration nrf52840_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD_PCA10056; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52840_XXAA; NRF_SD_BLE_API_VERSION=6; S140; SOFTDEVICE_PRESENT; SWI_DISABLE0
  ICCARM.CCIncludePath2: config; SDK\components; SDK\components\ble\ble_advertising; SDK\components\ble\ble_dtm; SDK\components\ble\ble_racp; SDK\components\ble\ble_services\ble_ancs_c; SDK\components\ble\ble_services\ble_ans_c; SDK\components\ble\ble_services\ble_bas; SDK\components\ble\ble_services\ble_bas_c; SDK\components\ble\ble_services\ble_cscs; SDK\components\ble\ble_services\ble_cts_c; SDK\components\ble\ble_services\ble_dfu; SDK\components\ble\ble_services\ble_dis; SDK\components\ble\ble_services\ble_gls; SDK\components\ble\ble_services\ble_hids; SDK\components\ble\ble_services\ble_hrs; SDK\components\ble\ble_services\ble_hrs_c; SDK\components\ble\ble_services\ble_hts; SDK\components\ble\ble_services\ble_ias; SDK\components\ble\ble_services\ble_ias_c; SDK\components\ble\ble_services\ble_lbs; SDK\components\ble\ble_services\ble_lbs_c; SDK\components\ble\ble_services\ble_lls; SDK\components\ble\ble_services\ble_nus; SDK\components\ble\ble_services\ble_nus_c; SDK\components\ble\ble_services\ble_rscs; SDK\components\ble\ble_services\ble_rscs_c; SDK\components\ble\ble_services\ble_tps; SDK\components\ble\common; SDK\components\ble\nrf_ble_gatt; SDK\components\ble\nrf_ble_qwr; SDK\components\ble\peer_manager; SDK\components\boards; SDK\components\libraries\atomic; SDK\components\libraries\atomic_fifo; SDK\components\libraries\atomic_flags; SDK\components\libraries\balloc; SDK\components\libraries\bootloader\ble_dfu; SDK\components\libraries\bsp; SDK\components\libraries\button; SDK\components\libraries\cli; SDK\components\libraries\crc16; SDK\components\libraries\crc32; SDK\components\libraries\crypto; SDK\components\libraries\csense; SDK\components\libraries\csense_drv; SDK\components\libraries\delay; SDK\components\libraries\ecc; SDK\components\libraries\experimental_section_vars; SDK\components\libraries\experimental_task_manager; SDK\components\libraries\fds; SDK\components\libraries\fstorage; SDK\components\libraries\gfx; SDK\components\libraries\gpiote; SDK\components\libraries\hardfault; SDK\components\libraries\hci; SDK\components\libraries\led_softblink; SDK\components\libraries\log; SDK\components\libraries\log\src; SDK\components\libraries\low_power_pwm; SDK\components\libraries\mem_manager; SDK\components\libraries\memobj; SDK\components\libraries\mpu; SDK\components\libraries\mutex; SDK\components\libraries\pwm; SDK\components\libraries\pwr_mgmt; SDK\components\libraries\queue; SDK\components\libraries\ringbuf; SDK\components\libraries\scheduler; SDK\components\libraries\sdcard; SDK\components\libraries\sensorsim; SDK\components\libraries\slip; SDK\components\libraries\sortlist; SDK\components\libraries\spi_mngr; SDK\components\libraries\stack_guard; SDK\components\libraries\strerror; SDK\components\libraries\svc; SDK\components\libraries\timer; SDK\components\libraries\twi_mngr; SDK\components\libraries\twi_sensor; SDK\components\libraries\usbd; SDK\components\libraries\usbd\class\audio; SDK\components\libraries\usbd\class\cdc; SDK\components\libraries\usbd\class\cdc\acm; SDK\components\libraries\usbd\class\hid; SDK\components\libraries\usbd\class\hid\generic; SDK\components\libraries\usbd\class\hid\kbd; SDK\components\libraries\usbd\class\hid\mouse; SDK\components\libraries\usbd\class\msc; SDK\components\libraries\util; SDK\components\nfc\ndef\conn_hand_parser; SDK\components\nfc\ndef\conn_hand_parser\ac_rec_parser; SDK\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser; SDK\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser; SDK\components\nfc\ndef\connection_handover\ac_rec; SDK\components\nfc\ndef\connection_handover\ble_oob_advdata; SDK\components\nfc\ndef\connection_handover\ble_pair_lib; SDK\components\nfc\ndef\connection_handover\ble_pair_msg; SDK\components\nfc\ndef\connection_handover\common; SDK\components\nfc\ndef\connection_handover\ep_oob_rec; SDK\components\nfc\ndef\connection_handover\hs_rec; SDK\components\nfc\ndef\connection_handover\le_oob_rec; SDK\components\nfc\ndef\generic\message; SDK\components\nfc\ndef\generic\record; SDK\components\nfc\ndef\launchapp; SDK\components\nfc\ndef\parser\message; SDK\components\nfc\ndef\parser\record; SDK\components\nfc\ndef\text; SDK\components\nfc\ndef\uri; SDK\components\nfc\t2t_lib; SDK\components\nfc\t2t_parser; SDK\components\nfc\t4t_lib; SDK\components\nfc\t4t_parser\apdu; SDK\components\nfc\t4t_parser\cc_file; SDK\components\nfc\t4t_parser\hl_detection_procedure; SDK\components\nfc\t4t_parser\tlv; SDK\components\softdevice\common; SDK\components\softdevice\s140\headers; SDK\components\softdevice\s140\headers\nrf52; SDK\components\toolchain\cmsis\include; SDK\external\fprintf; SDK\external\segger_rtt; SDK\external\utf_converter; SDK\integration\nrfx; SDK\integration\nrfx\legacy; SDK\modules\nrfx; SDK\modules\nrfx\drivers\include; SDK\modules\nrfx\hal; SDK\modules\nrfx\mdk; config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: SDK\components; SDK\components\ble\ble_advertising; SDK\components\ble\ble_dtm; SDK\components\ble\ble_racp; SDK\components\ble\ble_services\ble_ancs_c; SDK\components\ble\ble_services\ble_ans_c; SDK\components\ble\ble_services\ble_bas; SDK\components\ble\ble_services\ble_bas_c; SDK\components\ble\ble_services\ble_cscs; SDK\components\ble\ble_services\ble_cts_c; SDK\components\ble\ble_services\ble_dfu; SDK\components\ble\ble_services\ble_dis; SDK\components\ble\ble_services\ble_gls; SDK\components\ble\ble_services\ble_hids; SDK\components\ble\ble_services\ble_hrs; SDK\components\ble\ble_services\ble_hrs_c; SDK\components\ble\ble_services\ble_hts; SDK\components\ble\ble_services\ble_ias; SDK\components\ble\ble_services\ble_ias_c; SDK\components\ble\ble_services\ble_lbs; SDK\components\ble\ble_services\ble_lbs_c; SDK\components\ble\ble_services\ble_lls; SDK\components\ble\ble_services\ble_nus; SDK\components\ble\ble_services\ble_nus_c; SDK\components\ble\ble_services\ble_rscs; SDK\components\ble\ble_services\ble_rscs_c; SDK\components\ble\ble_services\ble_tps; SDK\components\ble\common; SDK\components\ble\nrf_ble_gatt; SDK\components\ble\nrf_ble_qwr; SDK\components\ble\peer_manager; SDK\components\boards; SDK\components\libraries\atomic; SDK\components\libraries\atomic_fifo; SDK\components\libraries\atomic_flags; SDK\components\libraries\balloc; SDK\components\libraries\bootloader\ble_dfu; SDK\components\libraries\bsp; SDK\components\libraries\button; SDK\components\libraries\cli; SDK\components\libraries\crc16; SDK\components\libraries\crc32; SDK\components\libraries\crypto; SDK\components\libraries\csense; SDK\components\libraries\csense_drv; SDK\components\libraries\delay; SDK\components\libraries\ecc; SDK\components\libraries\experimental_section_vars; SDK\components\libraries\experimental_task_manager; SDK\components\libraries\fds; SDK\components\libraries\fstorage; SDK\components\libraries\gfx; SDK\components\libraries\gpiote; SDK\components\libraries\hardfault; SDK\components\libraries\hci; SDK\components\libraries\led_softblink; SDK\components\libraries\log; SDK\components\libraries\log\src; SDK\components\libraries\low_power_pwm; SDK\components\libraries\mem_manager; SDK\components\libraries\memobj; SDK\components\libraries\mpu; SDK\components\libraries\mutex; SDK\components\libraries\pwm; SDK\components\libraries\pwr_mgmt; SDK\components\libraries\queue; SDK\components\libraries\ringbuf; SDK\components\libraries\scheduler; SDK\components\libraries\sdcard; SDK\components\libraries\sensorsim; SDK\components\libraries\slip; SDK\components\libraries\sortlist; SDK\components\libraries\spi_mngr; SDK\components\libraries\stack_guard; SDK\components\libraries\strerror; SDK\components\libraries\svc; SDK\components\libraries\timer; SDK\components\libraries\twi_mngr; SDK\components\libraries\twi_sensor; SDK\components\libraries\usbd; SDK\components\libraries\usbd\class\audio; SDK\components\libraries\usbd\class\cdc; SDK\components\libraries\usbd\class\cdc\acm; SDK\components\libraries\usbd\class\hid; SDK\components\libraries\usbd\class\hid\generic; SDK\components\libraries\usbd\class\hid\kbd; SDK\components\libraries\usbd\class\hid\mouse; SDK\components\libraries\usbd\class\msc; SDK\components\libraries\util; SDK\components\nfc\ndef\conn_hand_parser; SDK\components\nfc\ndef\conn_hand_parser\ac_rec_parser; SDK\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser; SDK\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser; SDK\components\nfc\ndef\connection_handover\ac_rec; SDK\components\nfc\ndef\connection_handover\ble_oob_advdata; SDK\components\nfc\ndef\connection_handover\ble_pair_lib; SDK\components\nfc\ndef\connection_handover\ble_pair_msg; SDK\components\nfc\ndef\connection_handover\common; SDK\components\nfc\ndef\connection_handover\ep_oob_rec; SDK\components\nfc\ndef\connection_handover\hs_rec; SDK\components\nfc\ndef\connection_handover\le_oob_rec; SDK\components\nfc\ndef\generic\message; SDK\components\nfc\ndef\generic\record; SDK\components\nfc\ndef\launchapp; SDK\components\nfc\ndef\parser\message; SDK\components\nfc\ndef\parser\record; SDK\components\nfc\ndef\text; SDK\components\nfc\ndef\uri; SDK\components\nfc\t2t_lib; SDK\components\nfc\t2t_parser; SDK\components\nfc\t4t_lib; SDK\components\nfc\t4t_parser\apdu; SDK\components\nfc\t4t_parser\cc_file; SDK\components\nfc\t4t_parser\hl_detection_procedure; SDK\components\nfc\t4t_parser\tlv; SDK\components\softdevice\common; SDK\components\softdevice\s140\headers; SDK\components\softdevice\s140\headers\nrf52; SDK\components\toolchain\cmsis\include; SDK\external\fprintf; SDK\external\segger_rtt; SDK\external\utf_converter; SDK\integration\nrfx; SDK\integration\nrfx\legacy; SDK\modules\nrfx; SDK\modules\nrfx\drivers\include; SDK\modules\nrfx\hal; SDK\modules\nrfx\mdk; config
  OBJCOPY.OOCOutputFile: ble_app_template_pca10056_s140.hex
  ILINK.IlinkOutputFile: ble_app_template_pca10056_s140.out
  ILINK.IlinkIcfFile: ble_app_template_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Log
    SDK/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Libraries
    SDK/components/libraries/button/: app_button.c
    SDK/components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    SDK/components/libraries/scheduler/: app_scheduler.c
    SDK/components/libraries/timer/: app_timer.c
    SDK/components/libraries/crc16/: crc16.c
    SDK/components/libraries/fds/: fds.c
    SDK/components/libraries/hardfault/: hardfault_implementation.c
    SDK/components/libraries/atomic_fifo/: nrf_atfifo.c
    SDK/components/libraries/atomic_flags/: nrf_atflags.c
    SDK/components/libraries/atomic/: nrf_atomic.c
    SDK/components/libraries/balloc/: nrf_balloc.c
    SDK/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    SDK/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    SDK/components/libraries/memobj/: nrf_memobj.c
    SDK/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    SDK/components/libraries/ringbuf/: nrf_ringbuf.c
    SDK/components/libraries/experimental_section_vars/: nrf_section_iter.c
    SDK/components/libraries/strerror/: nrf_strerror.c
    SDK/components/libraries/sensorsim/: sensorsim.c
  group None
    SDK/modules/nrfx/mdk/: iar_startup_nrf52840.s system_nrf52840.c
  group Board Definition
    SDK/components/boards/: boards.c
  group nRF_Drivers
    SDK/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c
    SDK/modules/nrfx/soc/: nrfx_atomic.c
    SDK/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_uart.c nrfx_uarte.c
    SDK/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group Board Support
    SDK/components/libraries/bsp/: bsp.c bsp_btn_ble.c
  group Application
    ../: main.c
    config/: sdk_config.h
  group nRF_Segger_RTT
    SDK/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_IAR.c SEGGER_RTT_printf.c
  group nRF_BLE
    SDK/components/ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c peer_manager_handler.c pm_buffer.c security_dispatcher.c security_manager.c
    SDK/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    SDK/components/ble/ble_advertising/: ble_advertising.c
    SDK/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    SDK/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group UTF8/UTF16 converter
    SDK/external/utf_converter/: utf.c
  group nRF_SoftDevice
    SDK/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
